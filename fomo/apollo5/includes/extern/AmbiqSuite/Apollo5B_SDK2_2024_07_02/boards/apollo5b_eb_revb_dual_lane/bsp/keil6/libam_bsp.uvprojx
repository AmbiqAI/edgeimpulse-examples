# Keil uVision project libam_bsp.uvprojx, settings and files
target libam_bsp (ARM-ADS)
  device: AMAP54KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.3.1
  cpu: IRAM(0x00000000,0x00040000) IRAM2(0x20000000,0x00080000) IROM(0x00400000,0x00400000) XRAM(0x20080000,0x00300000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP CLOCK(12000000) ELITTLE
  output: libam_bsp (library)
  c flags: Optim=6 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_PACKAGE_BGA AM_PART_APOLLO5B NEMA_PLATFORM=apollo5b_nemagfx keil6
  c include: ../../../../third_party/ThinkSi/NemaGFX_SDK/common/mem;../../../../CMSIS/AmbiqMicro/Include;../../../../mcu/apollo5b/hal/mcu;../../../../utils;../../../../mcu/apollo5b/hal;../../../../mcu/apollo5b;../../../../devices;../../../../third_party/ThinkSi/NemaGFX_SDK/NemaDC;../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaGFX;../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaDC;../../../../CMSIS/ARM/Include;../../../../third_party/ThinkSi/NemaGFX_SDK/NemaGFX;../../../../third_party/ThinkSi/config/apollo5b_nemagfx;../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/common
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT6: RAM 0x20080000 size 0x300000
  memory RVCT9: RAM 0x10000000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x80000
  group source_files
    ../: am_bsp.c am_bsp_pins.c
