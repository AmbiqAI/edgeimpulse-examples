# IAR project libam_bsp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP54KK-KBR AmbiqMicro AMAP54KK-KBR
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; AM_PART_APOLLO5B; NEMA_PLATFORM=apollo5b_nemagfx
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\common\mem; ..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\mcu\apollo5b\hal\mcu; ..\..\..\..\utils; ..\..\..\..\mcu\apollo5b\hal; ..\..\..\..\mcu\apollo5b; ..\..\..\..\devices; ..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaDC; ..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaGFX; ..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaDC; ..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaGFX; ..\..\..\..\third_party\ThinkSi\config\apollo5b_nemagfx; ..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: libam_bsp.bin
  ILINK.IlinkOutputFile: libam_bsp.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 4
  group (top)
    ../: am_bsp.c am_bsp_pins.c
