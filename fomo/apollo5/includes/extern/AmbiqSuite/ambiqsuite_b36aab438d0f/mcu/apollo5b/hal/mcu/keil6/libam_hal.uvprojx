# Keil uVision project libam_hal.uvprojx, settings and files
target libam_hal (ARM-ADS)
  device: AMAP54KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.3.1
  cpu: IRAM(0x00000000,0x00040000) IRAM2(0x20000000,0x00080000) IROM(0x00400000,0x00400000) XRAM(0x20080000,0x00300000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP CLOCK(12000000) ELITTLE
  output: libam_hal (library)
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_DEBUG_ASSERT AM_ASSERT_INVALID_THRESHOLD=0 AM_PART_APOLLO5B keil6
  c include: ../../../../../CMSIS/AmbiqMicro/Include;../../../../../CMSIS/ARM/Include;../../../../../utils;../../../../../mcu/apollo5b/hal;../../../../../mcu/apollo5b
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT6: RAM 0x20080000 size 0x300000
  memory RVCT9: RAM 0x10000000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x80000
  group mcu
    ../../../../../mcu/apollo5b/hal/mcu/: am_hal_syspll.c am_hal_tpiu.c am_hal_mspi.c am_hal_mcuctrl.c am_hal_utils.c am_hal_uart.c am_hal_debug.c am_hal_rtc.c am_hal_iom.c am_hal_sysctrl.c am_hal_sdhc.c am_hal_cachectrl.c am_hal_card.c am_hal_card_host.c am_hal_secure_ota.c am_hal_clkgen.c am_hal_mram.c am_hal_systick.c am_hal_cmdq.c am_hal_itm.c am_hal_mpu.c am_hal_interrupt.c am_hal_dsi.c am_hal_reset.c am_hal_bootrom_helper.c am_hal_ios.c
  group hal
    ../../../../../mcu/apollo5b/hal/: am_hal_dcu.c am_hal_infoc.c am_hal_audadc.c am_hal_wdt.c am_hal_access.c am_hal_pin.c am_hal_usb.c am_hal_pwrctrl.c am_hal_info.c am_hal_stimer.c am_hal_security.c am_hal_timer.c am_hal_clkmgr.c am_hal_i2s.c am_hal_global.c am_hal_gpdma.c am_hal_queue.c am_hal_pdm.c am_hal_gpio.c am_hal_adc.c
